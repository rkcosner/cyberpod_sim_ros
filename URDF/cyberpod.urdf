Commit message: Updated filter parameters

File: URDF/cyberpod.urdf (robot description, URDF)
Before this commit: robot cyberpod, 3 links, 2 joints
Joints:
- joint w2_joint: origin xyz=0 -.25 0 rpy=0 0 0 -> xyz=0 -0.25 0 rpy=0 0 0
